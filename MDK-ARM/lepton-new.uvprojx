# Keil uVision project lepton-new.uvprojx, settings and files
target lepton-new (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F415RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: lepton-new
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F415xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;..\image_process\inc;..\lepton\Inc;..\lepton_sdk\Inc;..\RADON\inc;..\tl1771\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f415xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal.c stm32f4xx_hal_i2c.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_tim.c stm32f4xx_hal_spi.c
  group Application/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group IMG_PROCESS
    ../image_process/src/: EasyTracer.c img_process.c template_match.c
  group LEPTON
    ../lepton/Src/: LEPTON_DRIVER.c lepton_i2c.c
  group LEPTON_SDK
    ../lepton_sdk/Src/: crc16fast.c LEPTON_AGC.c LEPTON_I2C_Protocol.c LEPTON_I2C_Service.c LEPTON_SDK.c LEPTON_SYS.c LEPTON_VID.c stm32_i2c.c
  group RADON
    ../RADON/src/: radon.c
  group TL1771
    ../tl1771/src/: TL1771_Driver.c
software components: CMSIS:CORE 4.1.0
